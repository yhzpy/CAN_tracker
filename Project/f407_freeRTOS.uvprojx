# Keil uVision project f407_freeRTOS.uvprojx, settings and files
target F407_freeRTOS (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Charge
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\Driver\BSP;..\Driver\CMSIS;..\Driver\FWLIB;..\Driver\FWLIB\inc;..\Driver\SYSTEM;..\Middle\FreeRTOS\include;..\Middle\FreeRTOS\portable\RVDS\ARM_CM4F;..\Middle;..\Middle\MALLOC;..\Middle\FATFS;..\User;..\Driver\BSP\LCD
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Driver/CMSIS
    ../Driver/CMSIS/: core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h startup_stm32f40_41xxx.s stm32f4xx.h system_stm32f4xx.c system_stm32f4xx.h
  group Driver/FWLIB
    ../Driver/FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
    ../Driver/FWLIB/: stm32f4xx_it.c stm32f4xx_conf.h
  group Driver/SYSTEM
    ../Driver/SYSTEM/: delay.c sys.c usart.c
  group Driver/BSP
    ../Driver/BSP/: LedKeyBeep.c OLED.c sdio_sdcard.c can.c RTC_driver.c RS485.c power_mgmt.c
  group Driver/LCD
    ../Driver/BSP/LCD/: lcd.c lcdfont.h
  group Middle/malloc
    ../Middle/MALLOC/: malloc.c
  group Middle/FreeRTOS_core
    ../Middle/FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group Middle/FreeRTOS_port
    ../Middle/FreeRTOS/portable/MemMang/: heap_4.c
    ../Middle/FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
  group Middle/FATFS
    ../Middle/FATFS/: diskio.c ff.c ffconf.h ffsystem.c ffunicode.c
  group User
    ../User/: FreeRTOSConfig.h main.c ymodem_protocol.c BMS279.c app.c
